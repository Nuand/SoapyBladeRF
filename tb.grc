options:
  parameters:
    generate_options: qt_gui
    id: tb
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 70e6
    step: 5e6
    stop: 6e9
    value: '2420000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '-10'
    step: '1'
    stop: '60'
    value: '38'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 61.44e6
  states: {}
- name: bladeRF_source_0
  id: bladeRF_source
  parameters:
    bias_tee0: 'False'
    bias_tee1: 'False'
    buffers: '512'
    buflen: '8192'
    bw: samp_rate/2
    dac: '10000'
    dc_calibration: LPF_TUNING
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    device_id: '0'
    feature: default
    fpga_image: ''
    fpga_reload: 'False'
    freq: freq
    gain0: gain
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    in_clk: ONBOARD
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    lpf_mode: disabled
    metadata: 'False'
    nchan: '1'
    out_clk: 'False'
    ref_clk: 10e6
    sample_format: 16bit_packed
    sample_rate: samp_rate
    sampling: internal
    show_pmic: 'False'
    smb: 38.4e6
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_ref_clk: 'False'
    verbosity: verbose
    xb200: none
  states: {state: disabled}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    type: complex
  states: {state: disabled}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant1: RX
    balance0: '0'
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: freq
    center_freq1: freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    dc_removal1: 'False'
    dev_args: feature=oversample
    devname: bladerf
    overall_gain0: gain
    overall_gain1: gain
    samp_rate: samp_rate
    stream_args: format=sc8_meta
    type: fc32
  states: {}

connections:
- [bladeRF_source_0, '0', fosphor_glfw_sink_c_0, '0']
- [soapy_source_0, '0', fosphor_glfw_sink_c_0, '0']
- [soapy_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
